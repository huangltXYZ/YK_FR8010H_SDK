# Keil uVision project ble_mesh.uvprojx, settings and files
target ble_mesh (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ble_mesh +hex
  AfterMake: fromelf.exe  --text  -c -o Output/ble_mesh.txt  Objects/ble_mesh.axf
  AfterMake: fromelf.exe  --bin -o Output/ble_mesh.bin  Objects/ble_mesh.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\components\ble\include;..\..\..\..\components\driver\include;..\..\..\..\components\modules\os\include;..\..\..\..\components\modules\sys\include;..\..\..\..\components\modules\platform\include;..\..\..\..\components\modules\common\include;..\..\..\..\components\modules\lowpow\include;..\..\..\..\components\modules\button;..\..\..\..\components\modules\sha256;..\..\..\..\components\modules\aes_cbc;..\..\..\..\components\ble\include\gap;..\..\..\..\components\ble\include\gatt;..\..\..\..\components\ble\include\mesh;..\..\..\..\components\ble\profiles\ble_ota;..\code;..\..\..\..\Source\APP;..\..\..\..\Source\BSP;..\..\..\..\Source\Common;..\..\..\..\Source\model_spec\generic_onoff;..\..\..\..\Source\model_spec\model_common;..\..\..\..\Source\model_spec\generic_dtt;..\..\..\..\Source\Profile;..\..\..\..\Source\model_spec\generic_ponoff;..\..\..\..\Source\model_spec\generic_level;..\..\..\..\Source\model_spec\light_lightness;..\..\..\..\Source\model_spec\light_ctl;..\..\..\..\Source\model_spec\light_hsl;..\..\..\..\Source\model_spec\light_status;..\..\..\..\Source\model_spec\sig_ota
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ble_5_0.sct
  link misc: --feedback=feedback.txt ../../../../components/ble/library/syscall.txt --entry=app_main --keep=_jump_table_reserved --keep=_jump_table_version --keep=_jump_table_image --keep=_jump_table_middle --keep=_jump_table_last --datacompressor=off
  group APP
    ../../../../Source/APP/: YK_Light_Config.h MEM_MAP.h YK_APP.c YK_APP.h APP_MEM.c APP_Platfrom.c APP_Google.c APP_Light.c APP_TC_OTA.c APP_MESH.c APP_BLE.c
  group BSP
    ../../../../Source/BSP/: BSP.c BSP.h FR801x_it.c BSP_TIMER.c BSP_UART.c BSP_LED.c BSP_PWM.c BSP_IIC.c BSP_SM2135EJ.c BSP_BP1658CJ.c BSP_IAP.c
  group Common
    ../../../../Source/Common/: Common.c Common.h
  group Model_Spec
    ../../../../Source/model_spec/model_common/: model_common.c
    ../../../../Source/model_spec/generic_onoff/: generic_onoff_server.c
    ../../../../Source/model_spec/generic_dtt/: generic_dtt_server.c
    ../../../../Source/model_spec/generic_ponoff/: generic_ponoff_setup_server.c
    ../../../../Source/model_spec/generic_level/: generic_level_server.c
    ../../../../Source/model_spec/light_lightness/: light_lightness_setup_server.c
    ../../../../Source/model_spec/light_ctl/: light_ctl_setup_server.c
    ../../../../Source/model_spec/light_hsl/: light_hsl_hue_server.c light_hsl_saturation_server.c light_hsl_setup_server.c
    ../../../../Source/model_spec/light_status/: light_status.c light_status.h
    ../../../../Source/model_spec/sig_ota/: blob_procedure_server.c blob_transfer_server.c firmware_update_procedure_server.c firmware_update_server.c
  group Profile
    ../../../../Source/Profile/: Google_Service.c TC_OTA_Service.c TC_OTA_Service.h
  group application
    ../code/: proj_main.c pb_remote_central.c sig_mesh_info.c sig_mesh_led.c
  group driver
    ../../../../components/driver/: driver_codec.c driver_efuse.c driver_i2s.c driver_iic.c driver_keyscan.c driver_pmu.c driver_pmu_pwm.c driver_pmu_qdec.c driver_ssp.c driver_timer.c driver_wdt.c driver_rtc.c driver_exti.c driver_uart.c driver_pwm.c
  group platform
    ../../../../components/modules/platform/source/: core_cm3_isr.c app_boot_vectors.s
  group patch
    ../../../../components/modules/patch/: patch.c
  group lib
    ../../../../components/ble/library/: fr8010h_stack.lib
  group module
    ../../../../components/modules/sha256/: sha256.c
    ../../../../components/modules/aes_cbc/: aes_cbc.c
